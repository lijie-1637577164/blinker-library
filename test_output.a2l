/* Generated by elf_map_to_a2l */
/* Date: 2026-08-20 07:19:43 */

ASAP2_VERSION 1 71
BEGIN_PROJECT TestProject

  "TestProject"

  BEGIN_MODULE TestProject

    "TestProject"

    BEGIN_MOD_PAR
      "TestProject parameters"

      VERSION "20260820_071943"

      ADDR_EPK 4

      BEGIN_MEMORY_SEGMENT SEC_interp
        ".interp section"
        PRG_TYPE PRG_CODE
        DATA_TYPE DTY_FLASH
        BEGIN_IF_DATA ADDRESS
          0x00000318
          0x00000334
        END_IF_DATA
      END_MEMORY_SEGMENT

      BEGIN_MEMORY_SEGMENT SEC_dynsym
        ".dynsym section"
        PRG_TYPE PRG_CODE
        DATA_TYPE DTY_FLASH
        BEGIN_IF_DATA ADDRESS
          0x000003D8
          0x00000468
        END_IF_DATA
      END_MEMORY_SEGMENT

      BEGIN_MEMORY_SEGMENT SEC_dynstr
        ".dynstr section"
        PRG_TYPE PRG_CODE
        DATA_TYPE DTY_FLASH
        BEGIN_IF_DATA ADDRESS
          0x00000468
          0x000004F0
        END_IF_DATA
      END_MEMORY_SEGMENT

      BEGIN_MEMORY_SEGMENT SEC_init
        ".init section"
        PRG_TYPE PRG_CODE
        DATA_TYPE DTY_FLASH
        BEGIN_IF_DATA ADDRESS
          0x00001000
          0x0000101B
        END_IF_DATA
      END_MEMORY_SEGMENT

      BEGIN_MEMORY_SEGMENT SEC_plt
        ".plt section"
        PRG_TYPE PRG_CODE
        DATA_TYPE DTY_FLASH
        BEGIN_IF_DATA ADDRESS
          0x00001020
          0x00001030
        END_IF_DATA
      END_MEMORY_SEGMENT

      BEGIN_MEMORY_SEGMENT SEC_text
        ".text section"
        PRG_TYPE PRG_CODE
        DATA_TYPE DTY_FLASH
        BEGIN_IF_DATA ADDRESS
          0x00001040
          0x000011AC
        END_IF_DATA
      END_MEMORY_SEGMENT

      BEGIN_MEMORY_SEGMENT SEC_fini
        ".fini section"
        PRG_TYPE PRG_CODE
        DATA_TYPE DTY_FLASH
        BEGIN_IF_DATA ADDRESS
          0x000011AC
          0x000011B9
        END_IF_DATA
      END_MEMORY_SEGMENT

      BEGIN_MEMORY_SEGMENT SEC_rodata
        ".rodata section"
        PRG_TYPE PRG_CODE
        DATA_TYPE DTY_FLASH
        BEGIN_IF_DATA ADDRESS
          0x00002000
          0x0000200C
        END_IF_DATA
      END_MEMORY_SEGMENT

      BEGIN_MEMORY_SEGMENT SEC_eh_frame_hdr
        ".eh_frame_hdr section"
        PRG_TYPE PRG_CODE
        DATA_TYPE DTY_FLASH
        BEGIN_IF_DATA ADDRESS
          0x0000200C
          0x00002048
        END_IF_DATA
      END_MEMORY_SEGMENT

      BEGIN_MEMORY_SEGMENT SEC_eh_frame
        ".eh_frame section"
        PRG_TYPE PRG_CODE
        DATA_TYPE DTY_FLASH
        BEGIN_IF_DATA ADDRESS
          0x00002048
          0x00002118
        END_IF_DATA
      END_MEMORY_SEGMENT

      BEGIN_MEMORY_SEGMENT SEC_init_array
        ".init_array section"
        PRG_TYPE PRG_CODE
        DATA_TYPE DTY_FLASH
        BEGIN_IF_DATA ADDRESS
          0x00003DF0
          0x00003DF8
        END_IF_DATA
      END_MEMORY_SEGMENT

      BEGIN_MEMORY_SEGMENT SEC_fini_array
        ".fini_array section"
        PRG_TYPE PRG_CODE
        DATA_TYPE DTY_FLASH
        BEGIN_IF_DATA ADDRESS
          0x00003DF8
          0x00003E00
        END_IF_DATA
      END_MEMORY_SEGMENT

      BEGIN_MEMORY_SEGMENT SEC_dynamic
        ".dynamic section"
        PRG_TYPE PRG_CODE
        DATA_TYPE DTY_FLASH
        BEGIN_IF_DATA ADDRESS
          0x00003E00
          0x00003FC0
        END_IF_DATA
      END_MEMORY_SEGMENT

      BEGIN_MEMORY_SEGMENT SEC_got
        ".got section"
        PRG_TYPE PRG_CODE
        DATA_TYPE DTY_FLASH
        BEGIN_IF_DATA ADDRESS
          0x00003FC0
          0x00004000
        END_IF_DATA
      END_MEMORY_SEGMENT

      BEGIN_MEMORY_SEGMENT SEC_data
        ".data section"
        PRG_TYPE PRG_CODE
        DATA_TYPE DTY_FLASH
        BEGIN_IF_DATA ADDRESS
          0x00004000
          0x00004028
        END_IF_DATA
      END_MEMORY_SEGMENT

      BEGIN_MEMORY_SEGMENT SEC_bss
        ".bss section"
        PRG_TYPE PRG_CODE
        DATA_TYPE DTY_FLASH
        BEGIN_IF_DATA ADDRESS
          0x00004040
          0x000040C0
        END_IF_DATA
      END_MEMORY_SEGMENT

    END_MOD_PAR

    BEGIN_MOD_COMMON
      "TestProject common"

      ALIGNMENT_BYTE 1
      ALIGNMENT_WORD 2
      ALIGNMENT_LONG 4
      ALIGNMENT_FLOAT32 4
      ALIGNMENT_FLOAT64 8
      ALIGNMENT_INT64 8
      ALIGNMENT_LONG64 8

      BYTE_ORDER LITTLE_ENDIAN

    END_MOD_COMMON

    BEGIN_COMPU_METHOD CM_NO_COMPU_METHOD
      "No conversion"
      IDENTICAL
      COMPU_TAB_REF "CM_NO_COMPU_METHOD_TAB"

      UNIT ""
      FORMAT "%.0"
    END_COMPU_METHOD

    BEGIN_COMPU_METHOD CM_LINEAR
      "Linear conversion y = x"
      LINEAR
      COMPU_TAB_REF "CM_LINEAR_TAB"

      COEFFS 1.0 0.0
      UNIT ""
      FORMAT "%.0"
    END_COMPU_METHOD

    BEGIN_COMPU_METHOD CM_DOUBLE
      "Double conversion y = 2*x"
      LINEAR
      COMPU_TAB_REF "CM_DOUBLE_TAB"

      COEFFS 2.0 0.0
      UNIT ""
      FORMAT "%.0"
    END_COMPU_METHOD

    BEGIN_COMPU_METHOD CM_HALVED
      "Halved conversion y = 0.5*x"
      LINEAR
      COMPU_TAB_REF "CM_HALVED_TAB"

      COEFFS 0.5 0.0
      UNIT ""
      FORMAT "%.0"
    END_COMPU_METHOD

    BEGIN_RECORD_LAYOUT RL_UBYTE
      "RL_UBYTE record layout"

      FNC_VALUES 1 UBYTE COLUMN_DIR DIRECT
    END_RECORD_LAYOUT

    BEGIN_RECORD_LAYOUT RL_SBYTE
      "RL_SBYTE record layout"

      FNC_VALUES 1 UBYTE COLUMN_DIR DIRECT
    END_RECORD_LAYOUT

    BEGIN_RECORD_LAYOUT RL_UWORD
      "RL_UWORD record layout"

      FNC_VALUES 1 UWORD COLUMN_DIR DIRECT
    END_RECORD_LAYOUT

    BEGIN_RECORD_LAYOUT RL_SWORD
      "RL_SWORD record layout"

      FNC_VALUES 1 UWORD COLUMN_DIR DIRECT
    END_RECORD_LAYOUT

    BEGIN_RECORD_LAYOUT RL_ULONG
      "RL_ULONG record layout"

      FNC_VALUES 1 ULONG COLUMN_DIR DIRECT
    END_RECORD_LAYOUT

    BEGIN_RECORD_LAYOUT RL_SLONG
      "RL_SLONG record layout"

      FNC_VALUES 1 ULONG COLUMN_DIR DIRECT
    END_RECORD_LAYOUT

    BEGIN_RECORD_LAYOUT RL_FLOAT32
      "RL_FLOAT32 record layout"

      FNC_VALUES 1 FLOAT32 COLUMN_DIR DIRECT
    END_RECORD_LAYOUT

    BEGIN_RECORD_LAYOUT RL_FLOAT64
      "RL_FLOAT64 record layout"

      FNC_VALUES 1 FLOAT64 COLUMN_DIR DIRECT
    END_RECORD_LAYOUT

    BEGIN_RECORD_LAYOUT RL_AULONGLONG
      "RL_AULONGLONG record layout"

      FNC_VALUES 1 A_ULONGLONG COLUMN_DIR DIRECT
    END_RECORD_LAYOUT

    BEGIN_RECORD_LAYOUT RL_A_SLONGLONG
      "RL_A_SLONGLONG record layout"

      FNC_VALUES 1 A_ULONGLONG COLUMN_DIR DIRECT
    END_RECORD_LAYOUT

    BEGIN_MEASUREMENT deregister_tm_clones
      "deregister_tm_clones measurement"
      CM_NO_COMPU_METHOD
      0
      READ

      BEGIN_IF_DATA ECU_ADDRESS
        0x00001070
      END_IF_DATA

      BEGIN_IF_DATA SYMBOL_TYPE
        ".text"
      END_IF_DATA

      BEGIN_IF_DATA DATA_SIZE
        4
      END_IF_DATA

    END_MEASUREMENT

    BEGIN_MEASUREMENT register_tm_clones
      "register_tm_clones measurement"
      CM_NO_COMPU_METHOD
      0
      READ

      BEGIN_IF_DATA ECU_ADDRESS
        0x000010A0
      END_IF_DATA

      BEGIN_IF_DATA SYMBOL_TYPE
        ".text"
      END_IF_DATA

      BEGIN_IF_DATA DATA_SIZE
        4
      END_IF_DATA

    END_MEASUREMENT

    BEGIN_MEASUREMENT frame_dummy
      "frame_dummy measurement"
      CM_NO_COMPU_METHOD
      0
      READ

      BEGIN_IF_DATA ECU_ADDRESS
        0x00001120
      END_IF_DATA

      BEGIN_IF_DATA SYMBOL_TYPE
        ".text"
      END_IF_DATA

      BEGIN_IF_DATA DATA_SIZE
        4
      END_IF_DATA

    END_MEASUREMENT

    BEGIN_MEASUREMENT _DYNAMIC
      "_DYNAMIC measurement"
      CM_NO_COMPU_METHOD
      0
      READ

      BEGIN_IF_DATA ECU_ADDRESS
        0x00003E00
      END_IF_DATA

      BEGIN_IF_DATA SYMBOL_TYPE
        ".dynamic"
      END_IF_DATA

      BEGIN_IF_DATA DATA_SIZE
        4
      END_IF_DATA

    END_MEASUREMENT

    BEGIN_MEASUREMENT _GLOBAL_OFFSET_TABLE_
      "_GLOBAL_OFFSET_TABLE_ measurement"
      CM_NO_COMPU_METHOD
      0
      READ

      BEGIN_IF_DATA ECU_ADDRESS
        0x00003FC0
      END_IF_DATA

      BEGIN_IF_DATA SYMBOL_TYPE
        ".got"
      END_IF_DATA

      BEGIN_IF_DATA DATA_SIZE
        4
      END_IF_DATA

    END_MEASUREMENT

    BEGIN_MEASUREMENT data_start
      "data_start measurement"
      CM_NO_COMPU_METHOD
      0
      READ

      BEGIN_IF_DATA ECU_ADDRESS
        0x00004000
      END_IF_DATA

      BEGIN_IF_DATA SYMBOL_TYPE
        ".data"
      END_IF_DATA

      BEGIN_IF_DATA DATA_SIZE
        4
      END_IF_DATA

    END_MEASUREMENT

    BEGIN_MEASUREMENT _edata
      "_edata measurement"
      CM_NO_COMPU_METHOD
      0
      READ

      BEGIN_IF_DATA ECU_ADDRESS
        0x00004028
      END_IF_DATA

      BEGIN_IF_DATA SYMBOL_TYPE
        ".data"
      END_IF_DATA

      BEGIN_IF_DATA DATA_SIZE
        4
      END_IF_DATA

    END_MEASUREMENT

    BEGIN_MEASUREMENT _fini
      "_fini measurement"
      CM_NO_COMPU_METHOD
      0
      READ

      BEGIN_IF_DATA ECU_ADDRESS
        0x000011AC
      END_IF_DATA

      BEGIN_IF_DATA SYMBOL_TYPE
        ".fini"
      END_IF_DATA

      BEGIN_IF_DATA DATA_SIZE
        4
      END_IF_DATA

    END_MEASUREMENT

    BEGIN_MEASUREMENT update_sensor
      "update_sensor measurement"
      CM_NO_COMPU_METHOD
      0
      READ

      BEGIN_IF_DATA ECU_ADDRESS
        0x00001129
      END_IF_DATA

      BEGIN_IF_DATA SYMBOL_TYPE
        ".text"
      END_IF_DATA

      BEGIN_IF_DATA DATA_SIZE
        53
      END_IF_DATA

    END_MEASUREMENT

    BEGIN_MEASUREMENT calibration_offset
      "calibration_offset measurement"
      CM_NO_COMPU_METHOD
      0
      READ

      BEGIN_IF_DATA ECU_ADDRESS
        0x00002004
      END_IF_DATA

      BEGIN_IF_DATA SYMBOL_TYPE
        ".rodata"
      END_IF_DATA

      BEGIN_IF_DATA DATA_SIZE
        2
      END_IF_DATA

    END_MEASUREMENT

    BEGIN_MEASUREMENT _IO_stdin_used
      "_IO_stdin_used measurement"
      CM_NO_COMPU_METHOD
      0
      READ

      BEGIN_IF_DATA ECU_ADDRESS
        0x00002000
      END_IF_DATA

      BEGIN_IF_DATA SYMBOL_TYPE
        ".rodata"
      END_IF_DATA

      BEGIN_IF_DATA DATA_SIZE
        4
      END_IF_DATA

    END_MEASUREMENT

    BEGIN_MEASUREMENT _end
      "_end measurement"
      CM_NO_COMPU_METHOD
      0
      READ

      BEGIN_IF_DATA ECU_ADDRESS
        0x000040C0
      END_IF_DATA

      BEGIN_IF_DATA SYMBOL_TYPE
        ".bss"
      END_IF_DATA

      BEGIN_IF_DATA DATA_SIZE
        4
      END_IF_DATA

    END_MEASUREMENT

    BEGIN_MEASUREMENT _start
      "_start measurement"
      CM_NO_COMPU_METHOD
      0
      READ

      BEGIN_IF_DATA ECU_ADDRESS
        0x00001040
      END_IF_DATA

      BEGIN_IF_DATA SYMBOL_TYPE
        ".text"
      END_IF_DATA

      BEGIN_IF_DATA DATA_SIZE
        38
      END_IF_DATA

    END_MEASUREMENT

    BEGIN_MEASUREMENT main
      "main measurement"
      CM_NO_COMPU_METHOD
      0
      READ

      BEGIN_IF_DATA ECU_ADDRESS
        0x0000116E
      END_IF_DATA

      BEGIN_IF_DATA SYMBOL_TYPE
        ".text"
      END_IF_DATA

      BEGIN_IF_DATA DATA_SIZE
        62
      END_IF_DATA

    END_MEASUREMENT

    BEGIN_MEASUREMENT get_counter
      "get_counter measurement"
      CM_NO_COMPU_METHOD
      0
      READ

      BEGIN_IF_DATA ECU_ADDRESS
        0x0000115E
      END_IF_DATA

      BEGIN_IF_DATA SYMBOL_TYPE
        ".text"
      END_IF_DATA

      BEGIN_IF_DATA DATA_SIZE
        16
      END_IF_DATA

    END_MEASUREMENT

    BEGIN_MEASUREMENT max_threshold
      "max_threshold measurement"
      CM_NO_COMPU_METHOD
      0
      READ

      BEGIN_IF_DATA ECU_ADDRESS
        0x00002008
      END_IF_DATA

      BEGIN_IF_DATA SYMBOL_TYPE
        ".rodata"
      END_IF_DATA

      BEGIN_IF_DATA DATA_SIZE
        4
      END_IF_DATA

    END_MEASUREMENT

    BEGIN_MEASUREMENT _init
      "_init measurement"
      CM_NO_COMPU_METHOD
      0
      READ

      BEGIN_IF_DATA ECU_ADDRESS
        0x00001000
      END_IF_DATA

      BEGIN_IF_DATA SYMBOL_TYPE
        ".init"
      END_IF_DATA

      BEGIN_IF_DATA DATA_SIZE
        4
      END_IF_DATA

    END_MEASUREMENT

    BEGIN_MEASUREMENT _0x30
      "0x30 measurement"
      CM_NO_COMPU_METHOD
      0
      READ

      BEGIN_IF_DATA ECU_ADDRESS
        0x00000338
      END_IF_DATA

      BEGIN_IF_DATA SYMBOL_TYPE
        ""
      END_IF_DATA

      BEGIN_IF_DATA DATA_SIZE
        4
      END_IF_DATA

    END_MEASUREMENT

    BEGIN_MEASUREMENT _0x24
      "0x24 measurement"
      CM_NO_COMPU_METHOD
      0
      READ

      BEGIN_IF_DATA ECU_ADDRESS
        0x00000368
      END_IF_DATA

      BEGIN_IF_DATA SYMBOL_TYPE
        ""
      END_IF_DATA

      BEGIN_IF_DATA DATA_SIZE
        4
      END_IF_DATA

    END_MEASUREMENT

    BEGIN_MEASUREMENT _0x0
      "0x0 measurement"
      CM_NO_COMPU_METHOD
      0
      READ

      BEGIN_IF_DATA ECU_ADDRESS
        0x00000500
      END_IF_DATA

      BEGIN_IF_DATA SYMBOL_TYPE
        ""
      END_IF_DATA

      BEGIN_IF_DATA DATA_SIZE
        4
      END_IF_DATA

    END_MEASUREMENT

    BEGIN_MEASUREMENT _0x18
      "0x18 measurement"
      CM_NO_COMPU_METHOD
      0
      READ

      BEGIN_IF_DATA ECU_ADDRESS
        0x00000530
      END_IF_DATA

      BEGIN_IF_DATA SYMBOL_TYPE
        ""
      END_IF_DATA

      BEGIN_IF_DATA DATA_SIZE
        4
      END_IF_DATA

    END_MEASUREMENT

    BEGIN_MEASUREMENT _0x8
      "0x8 measurement"
      CM_NO_COMPU_METHOD
      0
      READ

      BEGIN_IF_DATA ECU_ADDRESS
        0x00004008
      END_IF_DATA

      BEGIN_IF_DATA SYMBOL_TYPE
        ""
      END_IF_DATA

      BEGIN_IF_DATA DATA_SIZE
        4
      END_IF_DATA

    END_MEASUREMENT

    BEGIN_CHARACTERISTIC completed_0
      "completed.0 characteristic"
      VALUE
      0x00004040
      CM_NO_COMPU_METHOD
      0
      0

      BEGIN_IF_DATA ECU_ADDRESS
        0x00004040
      END_IF_DATA

      BEGIN_IF_DATA SYMBOL_TYPE
        ".bss"
      END_IF_DATA

      BEGIN_IF_DATA DATA_SIZE
        1
      END_IF_DATA

      RECORD_LAYOUT RL_UBYTE

    END_CHARACTERISTIC

    BEGIN_CHARACTERISTIC internal_buffer
      "internal_buffer characteristic"
      VALUE
      0x00004080
      CM_NO_COMPU_METHOD
      0
      0

      BEGIN_IF_DATA ECU_ADDRESS
        0x00004080
      END_IF_DATA

      BEGIN_IF_DATA SYMBOL_TYPE
        ".bss"
      END_IF_DATA

      BEGIN_IF_DATA DATA_SIZE
        64
      END_IF_DATA

      RECORD_LAYOUT RL_ULONG

    END_CHARACTERISTIC

    BEGIN_CHARACTERISTIC signed_long
      "signed_long characteristic"
      VALUE
      0x00004024
      CM_NO_COMPU_METHOD
      0
      0

      BEGIN_IF_DATA ECU_ADDRESS
        0x00004024
      END_IF_DATA

      BEGIN_IF_DATA SYMBOL_TYPE
        ".data"
      END_IF_DATA

      BEGIN_IF_DATA DATA_SIZE
        4
      END_IF_DATA

      RECORD_LAYOUT RL_ULONG

    END_CHARACTERISTIC

    BEGIN_CHARACTERISTIC precision_val
      "precision_val characteristic"
      VALUE
      0x00004018
      CM_NO_COMPU_METHOD
      0
      0

      BEGIN_IF_DATA ECU_ADDRESS
        0x00004018
      END_IF_DATA

      BEGIN_IF_DATA SYMBOL_TYPE
        ".data"
      END_IF_DATA

      BEGIN_IF_DATA DATA_SIZE
        8
      END_IF_DATA

      RECORD_LAYOUT RL_AULONGLONG

    END_CHARACTERISTIC

    BEGIN_CHARACTERISTIC signed_byte
      "signed_byte characteristic"
      VALUE
      0x00004020
      CM_NO_COMPU_METHOD
      0
      0

      BEGIN_IF_DATA ECU_ADDRESS
        0x00004020
      END_IF_DATA

      BEGIN_IF_DATA SYMBOL_TYPE
        ".data"
      END_IF_DATA

      BEGIN_IF_DATA DATA_SIZE
        1
      END_IF_DATA

      RECORD_LAYOUT RL_UBYTE

    END_CHARACTERISTIC

    BEGIN_CHARACTERISTIC sensor_value
      "sensor_value characteristic"
      VALUE
      0x00004060
      CM_NO_COMPU_METHOD
      0
      0

      BEGIN_IF_DATA ECU_ADDRESS
        0x00004060
      END_IF_DATA

      BEGIN_IF_DATA SYMBOL_TYPE
        ".bss"
      END_IF_DATA

      BEGIN_IF_DATA DATA_SIZE
        1
      END_IF_DATA

      RECORD_LAYOUT RL_UBYTE

    END_CHARACTERISTIC

    BEGIN_CHARACTERISTIC voltage
      "voltage characteristic"
      VALUE
      0x00004014
      CM_NO_COMPU_METHOD
      0
      0

      BEGIN_IF_DATA ECU_ADDRESS
        0x00004014
      END_IF_DATA

      BEGIN_IF_DATA SYMBOL_TYPE
        ".data"
      END_IF_DATA

      BEGIN_IF_DATA DATA_SIZE
        4
      END_IF_DATA

      RECORD_LAYOUT RL_ULONG

    END_CHARACTERISTIC

    BEGIN_CHARACTERISTIC counter
      "counter characteristic"
      VALUE
      0x00004064
      CM_NO_COMPU_METHOD
      0
      0

      BEGIN_IF_DATA ECU_ADDRESS
        0x00004064
      END_IF_DATA

      BEGIN_IF_DATA SYMBOL_TYPE
        ".bss"
      END_IF_DATA

      BEGIN_IF_DATA DATA_SIZE
        4
      END_IF_DATA

      RECORD_LAYOUT RL_ULONG

    END_CHARACTERISTIC

    BEGIN_CHARACTERISTIC temperature
      "temperature characteristic"
      VALUE
      0x00004010
      CM_NO_COMPU_METHOD
      0
      0

      BEGIN_IF_DATA ECU_ADDRESS
        0x00004010
      END_IF_DATA

      BEGIN_IF_DATA SYMBOL_TYPE
        ".data"
      END_IF_DATA

      BEGIN_IF_DATA DATA_SIZE
        2
      END_IF_DATA

      RECORD_LAYOUT RL_UWORD

    END_CHARACTERISTIC

    BEGIN_CHARACTERISTIC signed_word
      "signed_word characteristic"
      VALUE
      0x00004022
      CM_NO_COMPU_METHOD
      0
      0

      BEGIN_IF_DATA ECU_ADDRESS
        0x00004022
      END_IF_DATA

      BEGIN_IF_DATA SYMBOL_TYPE
        ".data"
      END_IF_DATA

      BEGIN_IF_DATA DATA_SIZE
        2
      END_IF_DATA

      RECORD_LAYOUT RL_UWORD

    END_CHARACTERISTIC

  END_MODULE

END_PROJECT
